PACKAGECONFIG:append = "sql-sqlite openssl no-opengl"
PACKAGECONFIG:remove = "examples tests"
QT_PTEST_ENABLED = "0"
