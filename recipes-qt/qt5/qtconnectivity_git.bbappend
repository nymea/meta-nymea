BBCLASSEXTEND += "native"

PACKAGECONFIG_remove_class-native = "bluez"
