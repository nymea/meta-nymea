PACKAGECONFIG[openssl] = "-openssl,-no-openssl,openssl"

PACKAGECONFIG += "openssl"
