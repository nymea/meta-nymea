FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

dirs755 += "/data"
